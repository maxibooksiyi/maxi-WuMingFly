# IAR project NamelessCotrunQuad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; ARM_MATH_CM3
  ICCARM.CCIncludePath2: Chip\inc; Chip\CMSIS; User; User\Driver\Inc; User\Controler\Inc; User\AHRS; Chip\CMSIS\startup\iar; Chip\DSP_Lib; User\Modules\Inc; Chip\USB\Core; Chip\USB\Config; Chip\USB; User\Controler\NCQ_Control
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: NamelessCotrunQuad.bin
  ILINK.IlinkOutputFile: NamelessCotrunQuad.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: Chip\inc; Chip\CMSIS; User; User\Driver\Inc; User\Controler\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Chip/DSP_Lib/FastMathFunctions
    Chip/DSP_Lib/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group Chip/DSP_Lib/MatrixFunctions
    Chip/DSP_Lib/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
  group Chip/Inc
    Chip/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Chip/Src
    Chip/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Chip/USB
    Chip/USB/: Queue.c
  group Chip/USB/Config
    Chip/USB/Config/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group Chip/USB/Core
    Chip/USB/Core/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group CMSIS
    Chip/CMSIS/startup/: startup_stm32f10x_hd.s
    Chip/CMSIS/: system_stm32f10x.c
  group User
    User/: Filter.c Headfile.h main.c stm32f10x_conf.h stm32f10x_it.c
  group User/AHRS
    User/AHRS/: Advanced_AHRS.c arm_math.h DoubleMatrix.c EKF.c EKF.h FastMath.c Matrix.c Quaternion.c
  group User/Controler/Inc
    User/Controler/Inc/: ADRC.h Calibration.h copyright.h Flight_Parameter_Table.h IMU.h NamelessCorun_Ctrl.h NamelessCorun_OpticalFlow.h PID.h SINS.h
  group User/Controler/NCQ_Control
    User/Controler/NCQ_Control/: control_althold.c control_althold.h control_config.h control_land.c control_land.h control_poshold.c control_poshold.h
  group User/Controler/Src
    User/Controler/Src/: ADRC.c Calibration.c copyright.o Flight_Control_Fault.c Flight_Parameter_Table.c IMU.c NamelessCorun_Ctrl.c namelesscorun_opticalflow.o NamelessCotrun_SDK.c OpticalFlow_Control.c PID.c SINS.c
  group User/Driver/Inc
    User/Driver/Inc/: Bling.h DELAY.h DHT11.h FBM320.h FLASH.h GPS.h HMC5883.h IIC.h IST8310.h KEY.h MPU6050.h MS5611.h NRF24L01.h OLED.h oledfont.h PPM.h PWM.h PX4FLOW.h SBUS.h SPI1.h SPI2.h SPL06_001.h srom.h SYSTEM.h TIME.h Time_Cnt.h US_100.h USART.h
    Chip/inc/: HW_I2C.h
  group User/Driver/Src
    User/Driver/Src/: ADC.c Bling.c delay.c FBM320.c FLASH.c GPS.c HMC5883.c IIC.c IST8310.c KEY.c MPU6050.c MS5611.c NRF24L01.c OLED.c OpticalFlow_LC306.c PPM.c PWM.c SBUS.c SPI2.c SPL06_001.c ssd1306.c SYSTEM.c TIME.c Time_Cnt.c US_100.c USART.c
  group User/Modules/Inc
    User/Modules/Inc/: CalibrationRoutines.h Earth_Declination.h
  group User/Modules/Src
    User/Modules/Src/: CalibrationRoutines.c Earth_Declination.c ringbuf.c
